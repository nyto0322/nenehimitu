# Keil uVision project pro.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC90C58RD+ Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(45000000) MODP2
  output: pro +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c DS18B02.c DS18B02.h LCD1602.c LCD1602.h OneWire.c OneWire.h Delay.c Delay.h
